# Keil uVision project myProject.uvprojx, settings and files
target N32G430 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LedBlink +hex
  AfterMake: fromelf --bin --output=.\bin\LedBlink.bin .\Objects\LedBlink.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\core;..\CMSIS\device;..\USER;..\FWILB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ../CMSIS/device/: system_n32g430.c
  group FWLB
    ../FWILB/src/: n32g430_rcc.c n32g430_gpio.c n32g430_usart.c misc.c n32g430_i2c.c n32g430_adc.c n32g430_flash.c
  group USER
    ../USER/: main.c n32g430_it.c log.c pmswitch.c keyinput.c i2c_drv.c oled.c ADCinput.c anotherinput.c pm25_usart.c myiic.c sht20.c SGP30.c flash_user.c
  group DELAY
    ../USER/: bsp_delay.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
